FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Applying-changes-from-Seeed-meta-st-odyssey-to-kirks.patch"

