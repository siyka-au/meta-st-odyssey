FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

UBOOT_SPLASH_LANDSCAPE_SRC = "aerolight-rgb-rle8-480x800.bmp"
UBOOT_SPLASH_PORTRAIT_SRC = "aerolight-rgb-rle8-480x288.bmp"